# Keil uVision project SPI_DMA_SLAVE.uvprojx, settings and files
target N32G030 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPI_DMA_SLAVE_SPI1 +hex
  AfterMake: fromelf --bin --output=.\bin\SPI_DMA_SLAVE_SPI1.bin .\Objects\SPI_DMA_SLAVE_SPI1.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G030, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32g030_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g030.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g030.c
  group FWLB
    ../../../../../../firmware/n32g030_std_periph_driver/src/: misc.c n32g030_dma.c n32g030_gpio.c n32g030_rcc.c n32g030_spi.c n32g030_usart.c
  group USER
    ../src/: main.c n32g030_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
