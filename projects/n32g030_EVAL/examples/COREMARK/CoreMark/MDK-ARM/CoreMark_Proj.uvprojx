# Keil uVision project CoreMark_Proj.uvprojx, settings and files
target N32G030 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.0.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CoreMark_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\CoreMark_Proj.bin .\Objects\CoreMark_Proj.axf
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G030, USE_STDPERIPH_DRIVER, SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  c include: ..\inc;..\coremark;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g030_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../startup/: startup_n32g030_CoreMark.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g030.c
  group FWLB
    ../../../../../../firmware/n32g030_std_periph_driver/src/: misc.c n32g030_crc.c n32g030_flash.c n32g030_gpio.c n32g030_rcc.c n32g030_usart.c
  group USER
    ../src/: main.c n32g030_it.c
  group COREMARK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../: readme.txt
