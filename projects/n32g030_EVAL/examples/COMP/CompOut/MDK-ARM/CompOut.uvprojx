# Keil uVision project CompOut.uvprojx, settings and files
target N32G030 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.0.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CompOut_Project
  AfterMake: fromelf --bin --output=.\bin\CompOut_Project.bin .\Objects\CompOut_Project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G030, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g030_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g030.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g030.c
  group FWLB
    ../../../../../../firmware/n32g030_std_periph_driver/src/: misc.c n32g030_comp.c n32g030_dbg.c n32g030_exti.c n32g030_gpio.c n32g030_rcc.c n32g030_tim.c n32g030_usart.c n32g030_adc.c n32g030_crc.c n32g030_dma.c n32g030_flash.c n32g030_i2c.c n32g030_iwdg.c n32g030_lptim.c n32g030_lpuart.c n32g030_opamp.c n32g030_pwr.c n32g030_rtc.c n32g030_spi.c n32g030_wwdg.c
  group USER
    ../src/: main.c n32g030_it.c
  group DOC
    ../: readme.txt
