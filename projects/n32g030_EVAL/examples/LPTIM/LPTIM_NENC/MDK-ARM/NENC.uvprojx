# Keil uVision project NENC.uvprojx, settings and files
target N32G030 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.0.1.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NENC +hex
  AfterMake: fromelf --bin --output=.\bin\NENC.bin .\Objects\NENC.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g030_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g030.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g030.c
  group USER
    ../src/: main.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g030_std_periph_driver/src/: n32g030_lptim.c n32g030_pwr.c n32g030_rcc.c misc.c n32g030_gpio.c
