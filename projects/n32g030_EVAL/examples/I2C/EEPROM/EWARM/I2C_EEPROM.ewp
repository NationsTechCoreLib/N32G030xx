# IAR project I2C_EEPROM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G030C8 Nations N32G030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G030; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSI_PLL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g030_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_EEPROM.bin
  ILINK.IlinkOutputFile: I2C_EEPROM.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g030.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g030_std_periph_driver/src/: misc.c n32g030_dma.c n32g030_flash.c n32g030_gpio.c n32g030_i2c.c n32g030_rcc.c n32g030_usart.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g030_EWARM.S
  group USER
    ../src/: i2c_eeprom.c main.c n32g030_it.c
