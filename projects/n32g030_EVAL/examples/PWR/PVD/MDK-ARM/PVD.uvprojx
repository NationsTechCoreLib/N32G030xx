# Keil uVision project PVD.uvprojx, settings and files
target N32G030 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: PVD +hex
  AfterMake: fromelf --bin --output=.\bin\PVD.bin .\Objects\PVD.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G030, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\N32G030_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_N32G030.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_N32G030.c
  group USER
    ../src/: main.c N32G030_it.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/N32G030_std_periph_driver/src/: N32G030_exti.c N32G030_pwr.c N32G030_rcc.c misc.c N32G030_gpio.c
