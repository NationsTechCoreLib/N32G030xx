# Keil uVision project Calendar.uvprojx, settings and files
target N32G030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G030C8 Nationstech
  pack: Nationstech.N32G030_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Calendar +hex
  AfterMake: fromelf --bin --output=.\bin\Calendar.bin .\Objects\Calendar.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G030, USE_STDPERIPH_DRIVER,
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g030_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g030.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g030.c
  group USER
    ../src/: main.c n32g030_it.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
  group FWLB
    ../../../../../../firmware/n32g030_std_periph_driver/src/: misc.c n32g030_exti.c n32g030_gpio.c n32g030_rtc.c n32g030_usart.c n32g030_rcc.c
